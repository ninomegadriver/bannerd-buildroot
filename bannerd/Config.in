## bannerd/Config.in
```kconfig
config BR2_PACKAGE_BANNERD
	bool "bannerd"
	help
	  A framebuffer animation daemon
	  https://github.com/alukichev/bannerd
```
